# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ../inc/: ST7735.c PLL.c Timer0A.c Timer1A.c Timer1A.h Timer2A.c Timer2A.h Sine.c Sine.h Timer0A.h SysTick.c SysTick.h
    ./: startup.s Lab3Main.c Display.c Display.h MainMenu.c MainMenu.h Time.c Time.h Alarm.c Alarm.h Timer.c Timer.h Stopwatch.c Stopwatch.h Menu.c Menu.h SetTime.c SetTime.h SetAlarms.c SetAlarms.h
software components: CMSIS:CORE 5.3.0
