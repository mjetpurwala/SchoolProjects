# Keil uVision project Baymax.uvprojx, settings and files
target Lab9 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab9.c Sound.h Sound.c Motor.c Motor.h SDCFile.h SD-LCD.c SD-LCD.h
    ../inc/: PLL.c SSD2119.c SSD2119.h Timer0A.h Timer0A.c TLV5616.c TLV5616.h Timer1A.c Timer1A.h ST7735.c Timer2A.c Timer2A.h UART.h UART.c esp8266.c MQTT.c UART5.c UART5.h esp8266.h Timer3A.c Timer3A.h
    ../lib/SDCFile_4C123/: ffconf.h diskio.h ff.h diskio.c ff.c integer.h SDCFile.c
software components: CMSIS:CORE 5.6.0
