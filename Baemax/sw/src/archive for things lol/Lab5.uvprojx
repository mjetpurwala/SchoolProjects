# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab5.c Transmitter.c Receiver.c Switch.c Switch.h Transmitter.h beat_detect.c led_matrix.c led_matrix.h
    ../inc/: Texas.c Timer0A.c Timer1A.c ST7735.c PLL.c dsp.c TLV5616.c cr4_fft_256_stm32.s cr4_fft_64_stm32.s cr4_fft_1024_stm32.s LED.c LED.h Timer2A.h Timer2A.c button.h checkbox.h grlib.h imageButton.h radioButton.h button.c checkbox.c circle.c context.c display.c image.c imageButton.c line.c radioButton.c rectangle.c string.c
software components: CMSIS:CORE 5.5.0
